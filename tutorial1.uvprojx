# Keil uVision project tutorial1.uvprojx, settings and files
target Tutorial (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tutorial1
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__FPU_PRESENT = 1,HSE_VALUE=8000000,ARM_MATH_CM4
  c include: .\Headers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source1
    ./: first_asm.s
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 2.4.2
